FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:my-k26-smk-sdt = " file://kria-common.cfg"
