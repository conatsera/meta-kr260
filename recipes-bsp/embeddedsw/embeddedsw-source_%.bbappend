FILESEXTRAPATHS:prepend := "${THISDIR}:"
#SRC_URI += "file://hooks.patch"