SRC_URI = "https://edf.amd.com/sswreleases/rel-v2025.2/image-recovery/2025.2/10090801/ImgRecovery.elf;name=k26-smk-sdt_ir https://edf.amd.com/sswreleases/rel-v2025.2/image-recovery/2025.2/10090801/web.img;name=k26-smk-sdt_web"

SRC_URI[k26-smk-sdt_ir.sha256sum] = 'f0eebf410b3397b70e2aa3f33d16cdb31e1699b64e75cbb0a2b7a00364f4ded5'
SRC_URI[k26-smk-sdt_web.sha256sum] = '0825518aea24c3104a58b0f847436db03a92d8d4366baad6594c4d03de09d8cb'