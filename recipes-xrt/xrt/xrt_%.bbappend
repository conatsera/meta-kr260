FILESEXTRAPATHS:prepend := "${THISDIR}:"
#SRC_URI += "file://dfx.patch"
