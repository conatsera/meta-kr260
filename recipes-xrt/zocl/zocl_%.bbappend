FILESEXTRAPATHS:prepend := "${THISDIR}:"
#SRC_URI += "file://zocl-break.patch"
